# IAR project tmplt_g070.ewp, settings and files
configuration tmplt_g070 (ARM, debug)
  General.OGChipSelectEditMenu: STM32G070RB ST STM32G070RB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_FULL_LL_DRIVER; USE_HAL_DRIVER; STM32G070xx; DBG_UART_ENABLE=1; DBG_PIN_ENABLE=1; configAPPLICATION_ALLOCATED_HEAP=1
  ICCARM.CCIncludePath2: ..\Core\Inc; ..\Libraries\STM32G0xx_HAL_Driver\Inc; ..\Libraries\STM32G0xx_HAL_Driver\Inc\Legacy; ..\Libraries\FreeRTOS\Source\include; ..\Libraries\FreeRTOS\Source\portable\IAR\ARM_CM0; ..\Libraries\CMSIS\Device\ST\STM32G0xx\Include; ..\Libraries\CMSIS\Include; ..\Utilities\uart_dbg; ..\Utilities\cmd_trmnl
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\Core\Inc
  OBJCOPY.OOCOutputFile: tmplt_g070.hex
  ILINK.IlinkOutputFile: tmplt_g070.out
  ILINK.IlinkIcfFile: ..\Core\Inc\stm32g070xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Core/Inc
    ../Core/Inc/: FreeRTOSConfig.h hooks.h main.h stm32_assert.h stm32g070xx_flash.icf stm32g0xx_hal_conf.h stm32g0xx_it.h
  group Core/Src
    ../Core/Src/: hooks.c main.c stm32g0xx_hal_msp.c stm32g0xx_it.c system_stm32g0xx.c
  group EWARM
    ./: startup_stm32g070xx.s
  group Libraries/CMSIS/Core/Include
    ../Libraries/CMSIS/Core/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h mpu_armv7.h mpu_armv8.h tz_context.h
  group Libraries/CMSIS/Device/ST/STM32G0xx/Include
    ../Libraries/CMSIS/Device/ST/STM32G0xx/Include/: stm32g070xx.h system_stm32g0xx.h
  group Libraries/CMSIS/Include
    ../Libraries/CMSIS/Include/: cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h mpu_armv7.h mpu_armv8.h tz_context.h
  group Libraries/FreeRTOS/Source
    ../Libraries/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Libraries/FreeRTOS/Source/include
    ../Libraries/FreeRTOS/Source/include/: atomic.h croutine.h event_groups.h FreeRTOS.h list.h message_buffer.h mpu_prototypes.h mpu_wrappers.h portable.h projdefs.h queue.h semphr.h stack_macros.h StackMacros.h stream_buffer.h task.h timers.h
  group Libraries/FreeRTOS/Source/portable/IAR/ARM_CM0
    ../Libraries/FreeRTOS/Source/portable/IAR/ARM_CM0/: port.c portasm.s portmacro.h
  group Libraries/FreeRTOS/Source/portable/MemMang
    ../Libraries/FreeRTOS/Source/portable/MemMang/: heap_4.c
  group Libraries/STM32G0xx_HAL_Driver/Inc
    ../Libraries/STM32G0xx_HAL_Driver/Inc/: stm32g0xx_hal.h stm32g0xx_hal_adc.h stm32g0xx_hal_adc_ex.h stm32g0xx_hal_cec.h stm32g0xx_hal_comp.h stm32g0xx_hal_cortex.h stm32g0xx_hal_crc.h stm32g0xx_hal_crc_ex.h stm32g0xx_hal_cryp.h stm32g0xx_hal_cryp_ex.h stm32g0xx_hal_dac.h stm32g0xx_hal_dac_ex.h stm32g0xx_hal_def.h stm32g0xx_hal_dma.h stm32g0xx_hal_dma_ex.h stm32g0xx_hal_exti.h stm32g0xx_hal_fdcan.h stm32g0xx_hal_flash.h stm32g0xx_hal_flash_ex.h stm32g0xx_hal_gpio.h stm32g0xx_hal_gpio_ex.h stm32g0xx_hal_hcd.h stm32g0xx_hal_i2c.h stm32g0xx_hal_i2c_ex.h stm32g0xx_hal_i2s.h stm32g0xx_hal_irda.h stm32g0xx_hal_irda_ex.h stm32g0xx_hal_iwdg.h stm32g0xx_hal_lptim.h stm32g0xx_hal_pcd.h stm32g0xx_hal_pcd_ex.h stm32g0xx_hal_pwr.h stm32g0xx_hal_pwr_ex.h stm32g0xx_hal_rcc.h stm32g0xx_hal_rcc_ex.h stm32g0xx_hal_rng.h stm32g0xx_hal_rtc.h stm32g0xx_hal_rtc_ex.h stm32g0xx_hal_smartcard.h stm32g0xx_hal_smartcard_ex.h stm32g0xx_hal_smbus.h stm32g0xx_hal_smbus_ex.h stm32g0xx_hal_spi.h stm32g0xx_hal_spi_ex.h stm32g0xx_hal_tim.h stm32g0xx_hal_tim_ex.h stm32g0xx_hal_uart.h stm32g0xx_hal_uart_ex.h stm32g0xx_hal_usart.h stm32g0xx_hal_usart_ex.h stm32g0xx_hal_wwdg.h stm32g0xx_ll_adc.h stm32g0xx_ll_bus.h stm32g0xx_ll_comp.h stm32g0xx_ll_cortex.h stm32g0xx_ll_crc.h stm32g0xx_ll_crs.h stm32g0xx_ll_dac.h stm32g0xx_ll_dma.h stm32g0xx_ll_dmamux.h stm32g0xx_ll_exti.h stm32g0xx_ll_gpio.h stm32g0xx_ll_i2c.h stm32g0xx_ll_iwdg.h stm32g0xx_ll_lptim.h stm32g0xx_ll_lpuart.h stm32g0xx_ll_pwr.h stm32g0xx_ll_rcc.h stm32g0xx_ll_rng.h stm32g0xx_ll_rtc.h stm32g0xx_ll_spi.h stm32g0xx_ll_system.h stm32g0xx_ll_tim.h stm32g0xx_ll_ucpd.h stm32g0xx_ll_usart.h stm32g0xx_ll_usb.h stm32g0xx_ll_utils.h stm32g0xx_ll_wwdg.h
  group Libraries/STM32G0xx_HAL_Driver/Inc/Legacy
    ../Libraries/STM32G0xx_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group Libraries/STM32G0xx_HAL_Driver/Src
    ../Libraries/STM32G0xx_HAL_Driver/Src/: stm32g0xx_hal.c stm32g0xx_hal_adc.c stm32g0xx_hal_adc_ex.c stm32g0xx_hal_cec.c stm32g0xx_hal_comp.c stm32g0xx_hal_cortex.c stm32g0xx_hal_crc.c stm32g0xx_hal_crc_ex.c stm32g0xx_hal_cryp.c stm32g0xx_hal_cryp_ex.c stm32g0xx_hal_dac.c stm32g0xx_hal_dac_ex.c stm32g0xx_hal_dma.c stm32g0xx_hal_dma_ex.c stm32g0xx_hal_exti.c stm32g0xx_hal_fdcan.c stm32g0xx_hal_flash.c stm32g0xx_hal_flash_ex.c stm32g0xx_hal_gpio.c stm32g0xx_hal_hcd.c stm32g0xx_hal_i2c.c stm32g0xx_hal_i2c_ex.c stm32g0xx_hal_i2s.c stm32g0xx_hal_irda.c stm32g0xx_hal_iwdg.c stm32g0xx_hal_lptim.c stm32g0xx_hal_pcd.c stm32g0xx_hal_pcd_ex.c stm32g0xx_hal_pwr.c stm32g0xx_hal_pwr_ex.c stm32g0xx_hal_rcc.c stm32g0xx_hal_rcc_ex.c stm32g0xx_hal_rng.c stm32g0xx_hal_rtc.c stm32g0xx_hal_rtc_ex.c stm32g0xx_hal_smartcard.c stm32g0xx_hal_smartcard_ex.c stm32g0xx_hal_smbus.c stm32g0xx_hal_smbus_ex.c stm32g0xx_hal_spi.c stm32g0xx_hal_spi_ex.c stm32g0xx_hal_tim.c stm32g0xx_hal_tim_ex.c stm32g0xx_hal_uart.c stm32g0xx_hal_uart_ex.c stm32g0xx_hal_usart.c stm32g0xx_hal_usart_ex.c stm32g0xx_hal_wwdg.c stm32g0xx_ll_adc.c stm32g0xx_ll_comp.c stm32g0xx_ll_crc.c stm32g0xx_ll_crs.c stm32g0xx_ll_dac.c stm32g0xx_ll_dma.c stm32g0xx_ll_exti.c stm32g0xx_ll_gpio.c stm32g0xx_ll_i2c.c stm32g0xx_ll_lptim.c stm32g0xx_ll_lpuart.c stm32g0xx_ll_pwr.c stm32g0xx_ll_rcc.c stm32g0xx_ll_rng.c stm32g0xx_ll_rtc.c stm32g0xx_ll_spi.c stm32g0xx_ll_tim.c stm32g0xx_ll_ucpd.c stm32g0xx_ll_usart.c stm32g0xx_ll_usb.c stm32g0xx_ll_utils.c
  group Utilities/cmd_trmnl
    ../Utilities/cmd_trmnl/: cmd_freertos_cntrl.c cmd_freertos_cntrl.h cmd_hdl.c cmd_hdl.h cmd_hlp.c cmd_hlp.h cmd_process.c cmd_process.h
  group Utilities/uart_dbg
    ../Utilities/uart_dbg/: pin_dbg.c pin_dbg.h printf_dbg.c printf_dbg.h uart_dbg.c uart_dbg.h
